# Keil uVision project stc15-car.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: stc15-car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group main
    ./: STARTUP.A51 main.c
  group hardware
    ./src/: led.c
